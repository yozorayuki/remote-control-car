# Keil uVision project Remote-Control-Car-master.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Remote-Control-Car-master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\MPU6050;.\SYSTEM\sys;.\WinterSky;.\YuukiDach
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group YuukiDach
    ./YuukiDach/: controller.c delay.c final_charge.c main.c mechanical_arm.c movement.c pca9685.c stm32f10x_it.c TIM.C ultrasonic.c
  group MPU6050
    ./MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
  group WinterSky
    ./WinterSky/: ADCConfig.c AutoControl.c LedConfig.c SysConfig.c UsartConfig.c WifiControl.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
